FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Set-finduuid-to-mmc-1-2-and-change-boot_targets.patch"
SRC_URI += "file://0002-Fix-finduuid-for-BBX15.patch"
